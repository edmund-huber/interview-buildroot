## package/watchdog_petter/Config.in
```kconfig
config BR2_PACKAGE_WATCHDOG_PETTER
bool "watchdog_petter"
default y
help
        Pets the watchdog
```
